# Keil uVision project gps.uvprojx, settings and files
target tiva-c (6140000::V6.14::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hosni
  c flags: Optim=2 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c include: .\drivers\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c
    ./drivers/src/: display.c gps.c i2c.c uart.c delay_timer.c led.c push_button.c time.c interrupt.c bluetooth.c ultrasonic.c
  group include
    ./drivers/include/: display.h gps.h i2c.h uart.h delay_timer.h led.h push_button.h time.h interrupt.h bluetooth.h ultrasonic.h
software components: CMSIS:CORE 5.4.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.0.1
